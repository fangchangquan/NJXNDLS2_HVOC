# Keil uVision project NJXNCGQKZQ.uvprojx, settings and files
target SourceCode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NJXNCGQKZQ +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c misc: --c99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\motor;..\SYSTEM;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\clock;..\SYSTEM\i2c;..\SYSTEM\ADC;..\SYSTEM\humidity;..\SYSTEM\no2sensor;..\SYSTEM\o3sensor;..\SYSTEM\pmsensor;..\SYSTEM\so2sensor;..\SYSTEM\temperature;..\SYSTEM\vocsensor;.\main;..\SYSTEM\light;..\SYSTEM\communication;..\SYSTEM\key;..\SYSTEM\iwdg;..\SYSTEM\digit_no2;..\SYSTEM\Fan_cmd;..\SYSTEM\digit_o3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./main/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h
  group USER
    ./main/: main.c stm32f4xx_it.c
  group SYSTEM
    ../SYSTEM/clock/: clock.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/motor/: motor.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/i2c/: I2C.C
    ../SYSTEM/ADC/: adc.c
    ../SYSTEM/temperature/: temp.c
    ../SYSTEM/humidity/: humidity.c
    ../SYSTEM/pmsensor/: pmsensor.c
    ../SYSTEM/vocsensor/: vocsensor.c
    ../SYSTEM/communication/: commu.c
    ../SYSTEM/light/: light.c
    ../SYSTEM/key/: key.c
    ../SYSTEM/iwdg/: iwdg.c
    ../SYSTEM/digit_no2/: digit_no2.c
    ../SYSTEM/Fan_cmd/: fan_cmd.c
    ../SYSTEM/digit_o3/: digit_o3.c
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_flash_ramfunc.c
